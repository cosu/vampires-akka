## conf/local.conf
```bitbake
include classpath("application.conf")

vampires {
  enabled-resources = [local, ssh]
  executors = ["fork"]
}
```
